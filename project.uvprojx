# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Library;.\Start;.\User;.\System;.\Hardware;.\Hardware\AD;.\Hardware\AHT20;.\Hardware\Calculator;.\Hardware\CH7800;.\Hardware\KEY;.\Hardware\Menu;.\Hardware\MPU6050;.\Hardware\OLED_SPI;.\Hardware\SU-21;.\Hardware\Time;.\Hardware\Voltage;.\Hardware\MPU6050\eMPL;.\FreeRTOS\include;.\FreeRTOS\port;.\Hardware\Game
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_wwdg.c
  group system
    ./System/: Delay.c Delay.h sys.c sys.h Timer.c Timer.h MyRTC.c MyRTC.h Serial1.c Serial1.h Serial2.c Serial2.h Serial3.c Serial3.h stm32_power.c stm32_power.h
  group Hardware
    ./Hardware/AD/: AD.c
    ./Hardware/AHT20/: AHT20.c
    ./Hardware/Calculator/: calculator.c
    ./Hardware/CH7800/: CH7800play.c
    ./Hardware/KEY/: Key.c
    ./Hardware/Menu/: menu.c menu_Data.c
    ./Hardware/Voltage/: voltage_mea.c
    ./Hardware/SU-21/: ASR_su_21t.c
    ./Hardware/OLED_SPI/: OLED_Data.c OLED.c
    ./Hardware/Time/: Time_page.c
    ./Hardware/MPU6050/: mpu_iic.c mpu6050.c StepCount.c
    ./Hardware/Game/: dino.c
    ./Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
